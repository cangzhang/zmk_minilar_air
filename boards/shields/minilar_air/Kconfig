## config/shields/minilar_air/Kconfig.shield
```kconfig
config SHIELD_MINILA_AIR
    bool "Minila Air"
    default y
    depends on SHIELD
```
